# Keil uVision project STM32C071_ST25R100.uvprojx, settings and files
target STM32C071_ST25R100 (6240000::V6.24::ARMCLANG)
  device: STM32C071RBTx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32C071_ST25R100 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ST25R200,USE_HAL_DRIVER,STM32C071xx
  c include: ../Core/Inc;../X-CUBE-NFC9/App;../X-CUBE-NFC9/Target;../Drivers/BSP/custom;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/NFC09A1;../Drivers/BSP/Components/st25r200;../Middlewares/ST/rfal/Inc;../Middlewares/ST/rfal/Src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ./: startup_stm32c071xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c bsp.c custom_bus.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Application/User/X-CUBE-NFC9/App
    ../X-CUBE-NFC9/App/: app_x-cube-nfcx.c
  group Application/User/X-CUBE-NFC9/Target
    ../X-CUBE-NFC9/Target/: nfc_conf.c demo_polling.c logger.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/st25r200/: rfal_rfst25r200.c st25r200.c st25r200_com.c st25r200_irq.c timer.c
  group Drivers/BSP/NFC
    ../Drivers/BSP/NFC09A1/: nfc09a1.c
  group Drivers/BSP/custom
    ../Drivers/BSP/custom/: custom.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_spi.c stm32c0xx_hal_spi_ex.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_cortex.c stm32c0xx_hal_exti.c stm32c0xx_hal_uart.c stm32c0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group Middlewares/X-CUBE-NFC9/Wireless/RFAL/Default_Config
    ../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_dpo.c rfal_iso15693_2.c rfal_cd.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
software components: CMSIS:CORE 5.6.0
